Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-12-06T14:38:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Dec 06 14:38:04 2022* Host: NCL-PI16* Database: C:\Users\haye\AppData\Local\Temp\{3827C5BD-C35B-4B52-BB95-6169A684CA4A}\ifc* Database version: 5507* Database creation date: Tue Dec 06 14:38:02 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Dec 06 14:38:02 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Dec 06 14:38:02 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: 4633R0RW, NBS_VilleroyAndBochAG_WcPns_MementoWashdownWCWallMounted4633R0:4633R0RW:429752
In: Level 0
Type - PredefinedType: TOILETPAN; Classification: Pr_40_20_93_94 (Uniclass2015); Material: NBS_VilleroyAndBoch_SanitaryCeramics_StoneWhite
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_WCPans_MementoWashdownWCWallMounted4633R0RW; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/y4rtwbqm; ProductInformation: https://pro.villeroy-boch.com/en/euo/bw/m/4633R0; Uniclass2015Title: WC pans; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Version: Products v1.22; Version: 7
Type - NBS_Data - ConnectingDimensions: n/a; ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; Depth: 560 mm; EmbodiedCarbon: n/a; Execution: n/a; Form: Wall-mounted, washdown; IntegralAccessories: Toilet seat and cover (8M24S1); MaterialsBody: Ceramic; MaterialsFinishAndColour: StoneWhite; Recyclability: n/a; RecycledContent: n/a; Standard: To BS EN 997; WaterSupplyOutletAndSeatHolesOutlet: Horizontal; WaterSupplyOutletAndSeatHolesSeatHoles: n/a; WaterSupplyOutletAndSeatHolesWaterSupply: Back inlet; Weight: 24.4 kg; Width: 0 mm
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: TOILETPAN
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_93_94:WC pans; CodePerformance: n/a; Color: StoneWhite; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Ceramic; ModelNumber: 4633R0RW; ModelReference: MementoWashdownWCWallMounted4633R0RW; Name: WCPans_MementoWashdownWCWallMounted4633R0RW_VilleroyAndBochAG; NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: Rectangle; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
